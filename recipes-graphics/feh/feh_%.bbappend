DEPENDS += "libxinerama"
EXTRA_OEMAKE = "curl=0 xinerama=1 PREFIX=/usr"
