PACKAGECONFIG:remove = "shell-desktop"
PACKAGECONFIG:remove = "screenshare"
PACKAGECONFIG:remove = "x11"
