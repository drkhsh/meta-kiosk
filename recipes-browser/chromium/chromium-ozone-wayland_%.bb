PACKAGECONFIG:remove = "upower"
